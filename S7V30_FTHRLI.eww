<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\S7V30_FTHRLI.ewp</path>
    </project>
    <batchBuild />
</workspace>
